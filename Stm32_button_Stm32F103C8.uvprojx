# Keil uVision project Stm32_button_Stm32F103C8.uvprojx, settings and files
target ROM (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Stm32_button_Stm32F103C8
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD
  c include: .\Inc;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Objects\Stm32_button_Stm32F103C8_ROM.sct
  group Source Group 1
    ./Src/: main.c button.c
target RAM (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: Stm32_button_Stm32F103C8
  c flags: Optim=2 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD, VECT_TAB_SRAM
  c include: .\Inc;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x20000000 size 0x2ffc
  memory RVCT9: RAM 0x20003000 size 0x1000
  scatter file: .\Objects\Stm32_button_Stm32F103C8_RAM.sct
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
